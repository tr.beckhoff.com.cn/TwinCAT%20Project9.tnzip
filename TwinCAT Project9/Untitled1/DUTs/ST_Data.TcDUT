{attribute 'pack_mode' := '1'} 
TYPE ST_Data :				
STRUCT
	str1	: WSTRING(32)	:= "你好";
	str2	: STRING(32)	:= 'hi';
	ivalue	: INT			:= 700;
	rvalue	: REAL			:= 3.1416;
END_STRUCT
END_TYPE
