PROGRAM MAIN
VAR
	HMI		: ST_Data;
END_VAR

END_PROGRAM
